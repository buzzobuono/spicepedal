.title Lowpass Active Filter (100 Hz)

R1 1 2 10k
C1 2 0 159.15e-9

* Opamp stage
R1 3 4 5k        ; feedback uscita → invertente
R2 4 0 10k       ; ingresso invertente → massa
OP 3 2 4 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

.input 1
.output 3
.probe lowpass-rc-active-non-inverting.csv V(1) V(4)

* Guadagno non-invertente = 1 + R1/R2 = 1 + 5k/10k = 1.5
