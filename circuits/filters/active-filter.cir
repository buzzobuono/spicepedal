* Bass Wah-Wah - High Gain Version
V1 1 0 DC 9

* --- Ingresso (Impedenza ricalibrata) ---
* Abbassiamo R_SERIE per far entrare il segnale
C1 2 3 0.22e-6
R_SERIE 3 4 33k

* --- Polarizzazione ---
* Valori classici per Q2N2222 in zona lineare
R1 1 4 470k
R2 4 0 100k

* --- Transistor ---
* Nodo 5=Collettore, 4=Base, 6=Emettitore
Q1 5 4 6 Q2N2222 Is=14.34e-15 Bf=255.9 Br=6.092 Vt=0.026
RC 1 5 10k
RE 6 0 100
CE 6 0 22e-6

* --- Rete Wah (LC Feedback) ---
C_WAH 5 8 47e-12
L1 8 10 200m

* Potenziometro di controllo (Sposta la risonanza)
P1 10 0 4 100k 0.5 LIN

* --- Uscita ---
C2 5 9 1e-6
Pvol 9 0 7 10k 0.9 LOG

.input 2
.output 7
.warmup 2
.probe af.csv V(2) V(7)
