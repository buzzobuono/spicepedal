.title Bass Guitar Band-Pass Filter 40Hz-5kHz

* Stage 1: High-Pass @ 40 Hz (elimina sub-bass e DC)
C_hp1 1 2 47e-6
R_hp1 2 0 100

* Stage 2: Low-Pass @ 5 kHz (elimina hiss e rumori)
L_lp1 2 3 6.4m
C_lp1 3 0 159e-6
R_damp 3 4 47

* Carico (simula input amplificatore)
Rload 4 0 1M

.input 1
.output 4
.probe bandpass_rlc.csv V(1) V(4)
