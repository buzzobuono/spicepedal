.title RL High-Pass Filter 100Hz

R1 1 2 1k
L1 2 0 1.59 Rs=100

.input 1
.output 2
.probe V(1) V(2)
