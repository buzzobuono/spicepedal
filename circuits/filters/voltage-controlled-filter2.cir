.title Simple Voltage Controlled Filter

VCC 10 0 DC 9
VEE 11 0 DC -9

Vctrl 2 0 DC 2.5
Vq 7 0 DC 0

C_in 1 3 0.1u
R_in 3 0 47k

R_mod1 3 4 47k
R_mod2 4 2 100k
C_mod1 4 5 0.033u
O1 5 4 5 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

R_res 5 8 10k
R_q 8 7 100k
R_fb 8 4 47k

R_out 5 6 10k

.output 6
.input 1

.probe voltage-controlled-filter.csv V(1) V(6)
