.title Lowpass Active Filter (100 Hz)

R1 1 2 10k
C1 2 0 159.15e-9

* Opamp stage
VCC 10 0 DC 15
VEE 11 0 DC -15
R1 2 3 10k
R2 3 4 100k

OP 4 0 3 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

.input 1
.output 4
.probe lowpass-rc-active.csv V(1) V(4)
