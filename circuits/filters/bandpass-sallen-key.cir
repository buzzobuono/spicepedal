.title Sallen-Key Band-Pass Filter

VCC 10 0 DC 15
VEE 11 0 DC -15

R1 1 2 10k
R2 2 3 10k
C1 2 4 22e-9
C2 3 0 22e-9

* Op-amp: Out In+ In- VCC VEE
OP 4 3 4 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

C1 4 5 220e-9
C2 5 6 220e-9
R1 5 7 10k
R2 6 0 10k

* Op-amp: Out In+ In- VCC VEE
OP 7 6 7 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

Bgain 8 0 V=10*V7

.input 1
.output 8
.probe bandpass-sallen-key.csv V(input) V(8)
