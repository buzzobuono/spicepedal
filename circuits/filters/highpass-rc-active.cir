.title High Active Filter (100 Hz)

C1 1 2 100e-9
R1 2 0 15.915k

* Opamp stage
VCC 10 0 DC 15
VEE 11 0 DC -15
R1 2 3 10k
R2 3 4 100k

OP 4 0 3 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

.input 1
.output 4
.probe highpass-rc-active.csv V(1) V(4)
