* Test OpAmp - Buffer Unity Gain

V1 4 0 DC 15
V2 5 0 DC -15
V3 1 0 DC 1.0

O1 2 1 3 4 5 TL072 Rout=75 Imax=0.020 Gain=1000 SR=13

W1 2 3

R1 2 0 10k

.input 1
.output 2

.probe test_buffer_unity.csv V(1) V(2) V(3)

*V(2) ≈ 1.0V
