* --- 1. LFO ---
B_LFO 10 0 V=1.5 + 0.8 * sin(2 * 3.1415 * 0.5 * t) Rs=1

* --- 2. OMEGA ---
B_OMEGA 20 0 V=2 * 3.1415 * (V10 * 1000) Rs=1

* --- 3. STADI ALL-PASS (Formula Implicita) ---
* Stadio 1
B_ST1_ST 31 0 V=(Vprev + V1 * V20 * dt) / (1 + V20 * dt)
B_ST1_OUT 32 0 V=V1 - 2 * V31

* Stadio 2
B_ST2_ST 41 0 V=(Vprev + V32 * V20 * dt) / (1 + V20 * dt)
B_ST2_OUT 42 0 V=V32 - 2 * V41

* --- 4. MIXER FINALE ---
B_OUT 4 0 V=4*(V1 + V42) Rs=1
.input 1
.output 4

.probe phaser.csv V(1) V(4)
