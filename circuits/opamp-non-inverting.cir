* Test OpAmp - Non-Inverting Amplifier (Gain = 2)

V1 4 0 DC 15
V2 5 0 DC -15
V3 1 0 DC 0.5

O1 3 1 2 4 5 TL072 Rout=75 Imax=0.020 Gain=10000 SR=13

R1 2 0 10k
R2 3 2 10k

.input 1
.output 3

.probe test_non_inverting.csv V(1) V(2) V(3)

*V(1) = 0.5V (input)
*V(2) ≈ 0.5V (feedback node)
*V(3) ≈ 1.0V (output = 2 × input)
