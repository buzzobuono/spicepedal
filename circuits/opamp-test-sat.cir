* Test Saturazione - Input Grande

* Alimentazione
V1 10 0 DC 15
V2 11 0 DC -15

* Input GRANDE per forzare saturazione
V4 1 0 DC 2.0      * 2V DC (enorme!)

* OpAmp gain = 10
O1 3 1 2 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 SR=13

R2 2 0 10k
R3 3 2 90k

.input 1
.output 3

.probe test_sat.csv V(1) V(2) V(3)
