* Test OpAmp - Verifica Base con Dual Supply

* Alimentazione
V1 10 0 DC 15
V2 11 0 DC -15

* Input DC
V4 1 0 DC 0.1      * 100mV DC

* OpAmp gain = 10
O1 3 1 2 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 SR=13

R2 2 0 10k
R3 3 2 90k         * Gain = 1 + 90k/10k = 10

.input 1
.output 3

.probe test_basic.csv V(1) V(2) V(3) V(10) V(11)
*V(1) = 0.1V (input)
*V(2) ≈ 0.1V (feedback, virtual ground)
*V(3) ≈ 1.0V (output = 10× input)
*Rails: ±15V
