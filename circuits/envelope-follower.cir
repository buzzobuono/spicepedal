* Envelope follower - follower corretto + diodo bassa soglia
VCC 10 0 DC 15
VEE 11 0 DC -15

* OpAmp in configurazione follower (minus collegato all'out)
O1 2 1 4 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13
W 2 4
* Diodo a bassa soglia
D1 2 3 D_LOW Is=1e-15 N=1 Vt=0.026 Cj0=2e-12 Vj=0.2 Mj=0.5

* RC envelope
C1 3 0 1e-3
R1 3 0 100k

.probe envelop_follower.csv V(1) V(2) V(3) V(10) V(11)
.output 2
.input 1
