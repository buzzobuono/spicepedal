.title Half Wave Rectifier

RS 1 2 1k
D1 2 3 1N4148 Is=5.3e-9 N=1.68 Vt=0.02585 Cj0=1.15e-12 Vj=0.74 Mj=0.02
RL 3 0 50k

.input 1
.output 3
.probe half-wave-rectifier.csv V(1) V(3)
