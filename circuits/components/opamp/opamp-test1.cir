* Test 1: Non-Inverting

V1 10 0 DC 15
V2 11 0 DC -15
V3 1 0 DC 0.5

O1 3 1 2 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

R1 2 0 10k
R2 3 2 10k

.input 1
.output 3

.probe test1.csv V(1) V(2) V(3)

*V(3) = 1.0V
