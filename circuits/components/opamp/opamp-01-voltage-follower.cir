.title Voltage Follower (Buffer)

VCC 10 0 DC 15
VEE 11 0 DC -15

OP 2 1 2 10 11 TL072

.input 1
.output 2
.include circuits/models/opamps.lib
.probe opamp-01-voltage-follower.csv V(1) V(2)
