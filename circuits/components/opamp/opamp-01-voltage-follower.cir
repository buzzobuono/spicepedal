.title Voltage Follower (Buffer)

VCC 10 0 DC 15
VEE 11 0 DC -15

OP 2 1 2 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

.input 1
.output 2
.probe opamp-01-voltage-follower.csv V(1) V(2)
