* Test 4: Buffer (con R feedback)

V1 10 0 DC 15
V2 11 0 DC -15
V3 1 0 DC 1.0

O1 2 1 3 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

R1 2 3 10

.input 1
.output 2

.probe test4.csv V(1) V(2) V(3)
*Atteso: V(2) ≈ 1.0V
