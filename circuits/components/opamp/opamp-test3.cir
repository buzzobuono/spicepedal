* Alimentazioni ±15V
VCC 10 0 DC 15
VEE 11 0 DC -15

* Ingresso DC per forzare differenza tra + e -
VIN 1 0 DC 5.0

* OpAmp TL072 senza feedback
O1 3 1 0 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

* Probing direttamente il nodo out dell'opamp
.output 3
.probe test_3.csv V(3)
