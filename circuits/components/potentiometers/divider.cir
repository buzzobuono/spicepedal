.title Partitore di tensione

VCC 1 0 DC 9.0
Pdivider 1 0 2 1M Pos=0.5 Taper=LIN

.input 1
.output 2
.probe divider.csv V(1)
V(2)
