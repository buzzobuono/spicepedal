.title Test Saturazione Visibile - Hard Clipping

V1 10 0 DC 5
V2 11 0 DC -5

O1 3 1 2 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 SR=13

R1 2 0 1k
R2 3 2 19k  * Gain = 20

.input 1
.output 3

.probe saturation.csv V(1) V(3)
