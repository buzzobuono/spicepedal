.title Three Oscillators - C Major Chord

VCC 10 0 DC 9
VEE 11 0 DC -9

R1a 3 1 10k
R2a 1 0 10k
C1a 2 1 0.1u
R3a 3 2 15k
O1a 1 2 3 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

R1b 6 4 10k
R2b 4 0 10k
C1b 5 4 0.1u
R3b 6 5 12k
O1b 4 5 6 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

R1c 9 7 10k
R2c 7 0 10k
C1c 8 7 0.1u
R3c 9 8 10k
O1c 7 8 9 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

R_mix1 3 12 33k
R_mix2 6 12 33k
R_mix3 9 12 33k

R_out 12 13 1k

.ic C1a 0.1
.ic C1b 0.1
.ic C1c 0.1

.output 13
.probe oscillator-cmaj.csv V(3) V(6) V(9)
