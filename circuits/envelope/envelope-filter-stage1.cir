* ------- ALIMENTAZIONE -------
VCC 10 0 DC 9
VEE 11 0 DC -9

* ------- ENVELOPE (modulazione = DC costante) -------
Venv 4 0 DC 0.5

* ------- BAND-PASS MFB -------
* Ingresso su nodo 3
* Frequenza modulata dal partitore (Rmod1/Rmod2)

Rin    3 5   22k
Rfb    6 5   100k
Rq     6 0   22k

C1     5 0   10e-9
C2     6 5   10e-9

* Nodo 5 è il punto che vuoi modulare.
* Modulo la frequenza variando l'impedenza vista da C1 con il partitore:

Rmod1 5 4   47k
Rmod2 4 0   2.7k

* Op-amp TL072 compatibile unOp
O2 6 5 6 10 11 TL072 Rout=75 Imax=0.020 Gain=1000 Sr=13

.input 3
.output 6
.probe bandpass.csv V(3) V(4) V(5) V(6)
