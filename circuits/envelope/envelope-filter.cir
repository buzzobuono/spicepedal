* Envelope Filter RC per basso elettrico - più aperto
VCC 10 0 DC 15
VEE 11 0 DC -15

* Follower ingresso
O1 2 1 2 10 11 TL072 Rout=75 Imax=0.020 Gain=10000 Sr=13

* Envelope follower
D1 2 3 D_LOW Is=1e-15 N=1 Vt=0.026 Cj0=2e-12 Vj=0.2 Mj=0.5
C1 3 0 1e-6
R1 3 0 47k

* RC LPF audio più aperto
R2 2 5 2.2k    ; ridotta rispetto a prima
C2 5 0 100e-9
O2 6 5 6 10 11 TL072 Rout=75 Imax=0.020 Gain=100000 Sr=13

.input 1
.output 6
.probe envelope_filter_open.csv V(1) V(2) V(3) V(5) V(6)
.warmup 60
